# Repository LuZening/RotatorInterface

## KiCad design PCB/interface_LAN_2/interface.kicad_pcb

Parts:
C1: 2.2uF 25V; 1206_C
C2: 100uF; CP_Radial_D5.0mm_P2.50mm
C3, C7, C12, C16, C17, C21, C25, C26, C39, C40, C41: 104; 0805_C
C4: 1000uF 63V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
C8, C14: 10uF; 0805_C
C9, C10, C27, C28: 1uF; 0805_C
C18, C24: 103; 0805_C
C19: 105; 0805_C
C20, C38: 1uF 50V; 1206_C
C22: 270p; 0805_C
C31: 1000uF 63V; CP_Radial_D16.0mm_P7.50mm
D1: 1N4007; SMA(DO-214AC)_S1
D2: 50V; SMA(DO-214AC)_S1
D3, D5, D6, D10: 16V; SMA(DO-214AC)_S1
D4: 16V; LL-34
D11, D12: LED_12; PinHeader_1x02_P2.54mm_Vertical
F1: 1A; 1206_R
J1: 24VAC; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal
J3: JTAG; PinHeader_1x04_P2.54mm_Vertical
J4: Power; PinSocket_2x05_P2.54mm_Vertical_SMD
J5: Control Signals; PinSocket_2x05_P2.54mm_Vertical_SMD
J6: HR913550A
J7: Sensor Feedback; PinSocket_2x05_P2.54mm_Vertical_SMD
J8: UART; PinHeader_1x04_P2.54mm_Vertical
J9, J11: POT; PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal
J10: LIMIT12; PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal
JP1: Prog; Jumper_3P
JP2, JP3: Jumper-3pin; Jumper_3P
JP4: VSEL; Jumper_3P
L1: bead; 0805_L
Q1: 8550; SOT-23(SOT-23-3)
Q2: TIP127; TO-252-2
Q3: MMBT5551; SOT-23(SOT-23-3)
R1, R2, R9, R10: 10K; 0805_R
R4, R11: 100K; 0805_R
R5, R32, R49: 1K; 0805_R
R6, R13, R16: 2.2K; 0805_R
R7: 18K 1%; 0805_R
R8: 10K 1%; 0805_R
R12: 51K; 0805_R
R14, R20, R21, R22, R33, R42: 10; 0805_R
R15, R17, R26, R27, R47: 4.7K; 0805_R
R18, R19, R34, R45: 100; 0805_R
R28, R48: 680 1/2; R_1812_4532Metric_Pad1.30x3.40mm_HandSolder
R29, R50: 220K; 0805_R
R30: 1K 1/2; R_1812_4532Metric_Pad1.30x3.40mm_HandSolder
R31: 1.5k; 0805_R
R35, R40, R41, R43: 49.9; 0805_R
R36, R38: 330; 0805_R
R37, R46: 18K; 0805_R
R39: 12.1K 1%; 0805_R
R51, R52: 51; 0805_R
R53: 1K1/2; R_1812_4532Metric_Pad1.30x3.40mm_HandSolder
R69, R70: 200; 0805_R
SC1, SC2, SC3, SC4: Screw_Terminal_01x01; M3_Screwhole
SW1: SW_SPST; SW_SPST_TS_1101
SW2: CW; K8-7071
SW3: CCW; K8-7071
SW4: SET; K8-7071
U1: B1205-1W; B0505-2W
U2: ESP32-WROOM-32
U3: LM317_TO-220; TO-252-2
U4: L78L05_SOT89; SOT-89(SOT-89-3)
U5: AMS1117-3.3; SOT-223
U6: OLED_128x32_4pin; SSD1306-0.91-OLED-4pin-128x32
U7: LAN8720A; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U9, U15: HCNR201; SMDIP-8_W11.48mm
U10, U12: EL357; SOP-4_P2.54
U14: LM358; SOIC-8_150MIL
U17: LMV358; SOIC-8_150MIL

Connections:
+3V3: C7.1, C9.1, C14.1, C17.1, C24.1, J5.2, J6.4, J6.5, J6.12 (LED_YA), J8.1, L1.1, R2.1, R6.2, R10.2, R15.2, R16.2, R26.2, R27.2, R31.1, R32.2, R35.2, R40.2, R41.2, R43.2, R47.1, R69.2, R70.2, U2.2 (VDD), U5.2 (VO), U6.2 (VCC), U7.9 (VDDIO), U17.8 (V+); also elsewhere on the board
+5VD: C12.1, U4.1 (OUT); also elsewhere on the board
+5VISO: C2.1, C3.1, C8.1, J7.2, R1.1, U1.4 (OUT+), U5.3 (VI)
+12V: C1.1, C10.1, C16.1, J4.10, R28.2, R30.2, R48.2, R53.2, U1.1 (IN+), U4.3 (IN), U10.1, U12.1, U14.8 (V+); also elsewhere on the board
/485RXD: R18.1, U2.34 (RXD0/IO3); also elsewhere on the board
/485TXD: R19.1, U2.35 (TXD0/IO1); also elsewhere on the board
/+24V: C38.1, R13.2, U3.2 (VO); also elsewhere on the board
/BOOT_PHYRST: JP1.2, R17.2, U2.25 (IO0)
/EMAC_CLK_OUT_180: R14.2, U2.28 (IO17)
/EMAC_RXD0: R20.2, U2.10 (IO25)
/EMAC_RXD1: R21.2, U2.11 (IO26)
/EMAC_RX_DRV: R22.2, U2.12 (IO27)
/EMAC_TXD0: U2.31 (IO19), U7.17 (TXD0)
/EMAC_TXD1: U2.36 (IO22), U7.18 (TXD1)
/EMAC_TX_EN: U2.33 (IO21), U7.16 (TXEN)
/INTX: U2.27 (IO16); also elsewhere on the board
/ISense1: J7.1, U2.4 (SENSOR_VP)
/ISense2: J7.3, U2.5 (SENSOR_VN)
/LEDAX: D11.2 (K)
/LEDBX: D12.2 (K); also elsewhere on the board
/LMTX1: U10.4; also elsewhere on the board
/LMTX2: R47.2, U12.4; also elsewhere on the board
/MDC: U2.37 (IO23), U7.13 (MDC)
/MDIO: R31.2, U2.30 (IO18), U7.12 (MDIO)
/PHY_VDDA: C18.1, C21.1, L1.2, U7.1 (VDD2A), U7.19 (VDD1A)
/POT1: C40.1, R34.2, U2.6 (IO34)
/POT2: C39.1, R45.2, U2.7 (IO35)
/PROG_RXD: J8.2, R18.2
/PROG_TXD: J8.3, R19.2
/RELOUT1: J5.1; also elsewhere on the board
/RELOUT2: J5.4; also elsewhere on the board
/RELOUT3: J5.3; also elsewhere on the board
/RELOUT4: J5.6; also elsewhere on the board
/RELOUT5: J5.5; also elsewhere on the board
/RELOUT6: J5.8; also elsewhere on the board
/RMII_TX_CLK: R14.1, U7.5 (XTAL1/CLKIN)
/RXN: J6.6 (RXN), R43.1, U7.22 (RXN)
/RXP: J6.3 (RXP), R41.1, U7.23 (RXP)
/SCL: R16.1, U2.8 (IO32), U6.3 (SCL); also elsewhere on the board
/SDA: R6.1, U2.9 (IO33), U6.4 (SDA); also elsewhere on the board
/SPWM1: R42.2, U2.24 (IO2)
/SPWM2: R33.1, U2.26 (IO4)
/SPWM3: J7.5, U2.29 (IO5)
/SPWM4_TDI: J3.1, J7.7, U2.14 (IO12)
/SPWM5_TCK: J3.3, J7.8, U2.16 (IO13)
/SPWM6_TMS: J3.4, J7.10, U2.13 (IO14)
/SW_CCW: R15.1, SW3.1 (A); also elsewhere on the board
/SW_CW: R26.1, SW2.1 (A); also elsewhere on the board
/SW_SET: R27.1, SW4.1 (A); also elsewhere on the board
/TDO: J3.2, U2.23 (IO15)
/TXN: J6.2 (TXN), R40.1, U7.20 (TXN)
/TXP: J6.1 (TXP), R35.1, U7.21 (TXP)
GND: C2.2, C3.2, C7.2, C8.2, C9.2, C14.2, C17.2, C18.2, C19.2, C21.2, C22.2, C24.2, C39.2, C40.2, C41.1, J5.9, J6.10 (LED_GK), J7.9, J8.4, JP1.3, R1.2, R39.2, SW1.1 (A), SW2.2 (B), SW3.2 (B), SW4.2 (B), U1.3 (OUT-), U2.1 (GND), U2.15 (GND), U2.38 (GND), U2.39 (GND), U5.1 (GND), U6.1 (GND), U7.25 (VSS), U9.5, U10.3, U12.3, U15.5, U17.3 (+), U17.4 (V-), U17.5 (+); also elsewhere on the board
GNDPWR: C1.2, C4.2, C10.2, C12.2, C16.2, C20.2, C25.2, C26.2, C27.2, C28.2, C31.2, C38.2, D2.2 (A2), D3.2 (A2), D5.2 (A2), D6.2 (A2), D10.2 (A2), J1.1, J4.1, J4.3, J4.5, J4.7, J4.9, J6.8 (GND), J10.3, Q3.2 (E), R4.2, R8.2, R11.2, R12.2, R51.2, R52.2, U1.2 (IN-), U4.2 (GND), U9.4, U14.3 (+), U14.4 (V-), U14.5 (+), U15.4; also elsewhere on the board
unnamed: C19.1, C22.1, U7.6 (VDDCR)
unnamed: C20.1, Q2.2 (C), U3.3 (VI)
unnamed: C25.1, D5.1 (A1), R5.2, U10.2
unnamed: C26.1, D6.1 (A1), R49.1, U12.2
unnamed: C27.1, D3.1 (A1), J11.2, JP3.2, R50.2
unnamed: C28.1, D10.1 (A1), J9.2, JP2.2, R29.2
unnamed: C4.1, C31.1, D1.2 (K), Q1.2 (E), Q2.3 (E), R7.1
unnamed: C41.2, R37.2, U15.6, U17.2 (-)
unnamed: D1.1 (A), D2.1 (A1), F1.1
unnamed: D4.1 (A), Q3.1 (B)
unnamed: D4.2 (K), R7.2, R8.1
unnamed: D11.1 (A), R69.1
unnamed: D12.1 (A), R70.1
unnamed: J5.7, R42.1
unnamed: J5.10, R33.2
unnamed: J6.9 (LED_GA), R36.1
unnamed: J6.11 (LED_YK), R38.1
unnamed: J9.1, JP2.3, R30.1
unnamed: J9.3, R52.1
unnamed: J10.1, R5.1
unnamed: J10.2, R49.2
unnamed: J11.1, JP3.3, R53.1
unnamed: J11.3, R51.1
unnamed: JP1.1, R10.1
unnamed: JP4.1, JP4.2, R12.1, R13.1, U3.1 (ADJ)
unnamed: JP4.3, R4.1
unnamed: Q1.1 (B), R9.1
unnamed: Q1.3 (C), Q2.1 (B), R11.1
unnamed: Q3.3 (C), R9.2
unnamed: R2.2, SW1.2 (B), U2.3 (EN)
unnamed: R17.1, U7.15 (RST)
unnamed: R20.1, U7.8 (RXD0/MODE0)
unnamed: R21.1, U7.7 (RXD1/MODE1)
unnamed: R22.1, U7.11 (CRS_DV/MODE2)
unnamed: R28.1, U15.2
unnamed: R29.1, U14.2 (-), U15.3
unnamed: R32.1, U7.10 (RXER/PHYAD0)
unnamed: R34.1, R37.1, U17.1
unnamed: R36.2, U7.3 (LED1/REGOFF)
unnamed: R38.2, U7.2 (LED2/nINTSEL)
unnamed: R39.1, U7.24 (RBIAS)
unnamed: R45.1, R46.1, U17.7
unnamed: R46.2, U9.6, U17.6 (-)
unnamed: R48.1, U9.2
unnamed: R50.1, U9.3, U14.6 (-)
unnamed: U14.1, U15.1
unnamed: U9.1, U14.7
VAC: F1.2, J1.2, J4.2, J4.4, J4.6, J4.8

Notes on the sheet:
CPU POWER
0.1-1V
Angular Signal Aquisition 1
Power Supply
Angular Signal Aquisition2
Ground To Program
RS485 POWER
OLED I2C ADDR: 0x3C
Display
50MHz REFCLK from ESP32
High for CLKin
OV protection
IO34\35 Input Only Pins
0: SET 1/2: CCW 2/3: CW 3/4: None
Input Only Pins
ADC1_6
ADC1_7
ADC1_0
ADC1_3
VDD_SDIO PD
BOOT2 PD
LOG PU(print) PD(cancel)
Cancel Log Out
Manual Control
nINTSEL=1 REFCLK in
REGOFF=0: Use Internal 1.2V
OPAMP must be Ground Sensing
H: Out 31V
L: Out 21V
Jump to saving mode when: VDC in <= 33V VAC in <= 23V

Notes on the sheet:
ADD: 0010 0[A2-0] 0x20

Parts:
C6: 10uF 63V; 1210_C
C13: 104; 0805_C
C15: 330pF; 0805_C
C23: 10uF; 1210_C
C29: 47uF 25V; CP_Elec_6.3x5.9
D9: SS34; SMA(DO-214AC)_S1
L2: 22uH 2A; L_Taiyo-Yuden_NR-50xx
R3, R64: 47K; 0805_R
R65: 150K; 0805_R
R66: 10K; 0805_R
RV1: 10K; Potentiometer_Bourns_3224W_Vertical
U11: LMR16020; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.514x3.2mm_ThermalVias

Connections:
+12V: C15.1, C23.1, C29.1, L2.2, R65.1; also elsewhere on the board
/+24V: C6.1, U11.2 (VIN), U11.3 (EN); also elsewhere on the board
GNDPWR: C6.2, C23.2, C29.2, D9.1 (A), R64.2, R66.2, RV1.2, RV1.3, U11.0, U11.7 (GND), U11.9; also elsewhere on the board
unnamed: C13.1, D9.2 (K), L2.1, U11.8 (SW)
unnamed: C13.2, U11.1 (BOOT)
unnamed: C15.2, R65.2, R66.1, U11.5 (FB)
unnamed: R3.1, R64.1, U11.4 (RT/SYNC)
unnamed: R3.2, RV1.1

Notes on the sheet:
RT =22.5k-19.4k f = 1.04MHz-1.19MHz

Board: 4 copper layers, 100.0 x 75.0 mm, 160 parts (3 on the bottom side), 117 nets.

Other parts of the board:
C5, C30: 104; 0805_C
D7, D8: 5.6V; SMA(DO-214AC)_S1
F2, F3: 6.8V0.1A; 0805_R
J12: RS485; PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal
R54: 200; 0805_R
R55: 220; 0805_R
R56, R57, R58, R60, R62: 1K; 0805_R
R59: 4.7K; 0805_R
R61: 120; 0805_R
U8: PCA9555PW; TSSOP-24_4.4x7.8mm_P0.65mm
U18, U19, U20: EL357; SOP-4_P2.54
U21: MAX485E; SOIC-8_150MIL

Their connections:
+3V3: C5.2, R54.1, R55.1, R56.1, U8.24; also elsewhere on the board
+5VD: C30.1, R57.2, R58.1, R62.1, U19.4, U21.8; also elsewhere on the board
/485RW: U8.13, U19.2
/485RXD: R56.2, U20.4; also elsewhere on the board
/485TXD: U18.2; also elsewhere on the board
/INTX: U8.1; also elsewhere on the board
/LEDBX: U8.5; also elsewhere on the board
/LMTX1: U8.14; also elsewhere on the board
/LMTX2: U8.15; also elsewhere on the board
/RELOUT1: U8.6; also elsewhere on the board
/RELOUT2: U8.7; also elsewhere on the board
/RELOUT3: U8.8; also elsewhere on the board
/RELOUT4: U8.9; also elsewhere on the board
/RELOUT5: U8.10; also elsewhere on the board
/RELOUT6: U8.11; also elsewhere on the board
/RS485/A485: F3.1, J12.3
/RS485/B485: F2.1, J12.1
/SCL: U8.22; also elsewhere on the board
/SDA: U8.23; also elsewhere on the board
/SW_CCW: U8.17; also elsewhere on the board
/SW_CW: U8.18; also elsewhere on the board
/SW_SET: U8.16; also elsewhere on the board
GND: C5.1, U8.2, U8.3, U8.12, U8.21, U20.3; also elsewhere on the board
GNDPWR: C30.2, D7.2, D8.1, J12.2, R59.2, R60.2, U18.3, U21.5; also elsewhere on the board
unnamed: D7.1, F2.2, R60.1, R61.2, U21.7
unnamed: D8.2, F3.2, R61.1, R62.2, U21.6
unnamed: R54.2, U18.1
unnamed: R55.2, U19.1
unnamed: R57.1, U20.1
unnamed: R58.2, U18.4, U21.4
unnamed: R59.1, U19.3, U21.2, U21.3
unnamed: U20.2, U21.1

File PCB/interface_LAN_2/interface_BOM.csv:

Comment,Description,Designator,Footprint,LibRef,Pins,Quantity,PartNumber,url,¹ºÂò
2.2uF 25V,desc,"C1,",1206_C,libref,2,1,,,STK
104,desc,"C3,C5,C7,C12,C13,C16,C17,C21,C25,C26,C30,C39,C40,C41,",0805_C,libref,2,14,,,STK
10uF 63V,desc,"C6,",1210_C,libref,2,1,,,STK
10uF,desc,"C8,C14,",0805_C,libref,2,2,,,STK
1uF,desc,"C9,C10,C27,C28,",0805_C,libref,2,4,,,STK
330pF,desc,"C15,",0805_C,libref,2,1,,,STK
103,desc,"C18,C24,",0805_C,libref,2,2,,,STK
105,desc,"C19,",0805_C,libref,2,1,,,STK
1uF 50V,desc,"C20,C38,",1206_C,libref,2,2,,,STK
270p,desc,"C22,",0805_C,libref,2,1,,,STK
10uF,desc,"C23,",1210_C,libref,2,1,,,STK
47uF 25V,desc,"C29,",CP_Elec_6.3x5.9,libref,2,1,,,LC
1N4007,desc,"D1,",SMA(DO-214AC)_S1,libref,2,1,,,STK
50V,desc,"D2,",SMA(DO-214AC)_S1,libref,2,1,,,LC
16V,desc,"D3,D5,D6,D10,",SMA(DO-214AC)_S1,libref,2,4,,,LC
16V,desc,"D4,",LL-34,libref,2,1,,,
5.6V,desc,"D7,D8,",SMA(DO-214AC)_S1,libref,2,2,,,LC
SS34,desc,"D9,",SMA(DO-214AC)_S1,libref,2,1,,,LC
1A,desc,"F1,",1206_R,libref,2,1,,,STK
6.8V0.1A,desc,"F2,F3,",0805_R,libref,2,2,,,STK
bead,desc,"L1,",0805_L,libref,2,1,,,STK
22uH 2A,desc,"L2,",L_Taiyo-Yuden_NR-50xx,libref,2,1,,,LC_BOUGHT
8550,desc,"Q1,",SOT-23(SOT-23-3),libref,3,1,,,STK
TIP127,desc,"Q2,",TO-252-2,libref,7,1,,,STK
MMBT5551,desc,"Q3,",SOT-23(SOT-23-3),libref,3,1,,,STK
10K,desc,"R1,R2,R9,R10,R66,",0805_R,libref,2,5,,,STK
100K,desc,"R4,R11,",0805_R,libref,2,2,,,STK
1K,desc,"R5,R32,R49,R56,R57,R58,R60,R62,",0805_R,libref,2,8,,,STK
2.2K,desc,"R6,R13,R16,",0805_R,libref,2,3,,,STK
18K 1%,desc,"R7,",0805_R,libref,2,1,,,STK
10K 1%,desc,"R8,",0805_R,libref,2,1,,,STK
51K,desc,"R12,",0805_R,libref,2,1,,,STK
10,desc,"R14,R20,R21,R22,R33,R42,",0805_R,libref,2,6,,,STK
4.7K,desc,"R15,R17,R26,R27,R47,R59,",0805_R,libref,2,6,,,STK
100,desc,"R18,R19,R34,R45,",0805_R,libref,2,4,,,STK
680 1/2,desc,"R28,R48,",R_1812_4532Metric_Pad1.30x3.40mm_HandSolder,libref,2,2,,,STK
220K,desc,"R29,R50,",0805_R,libref,2,2,,,STK
1K 1/2,desc,"R30,",R_1812_4532Metric_Pad1.30x3.40mm_HandSolder,libref,2,1,,,STK
1.5k,desc,"R31,",0805_R,libref,2,1,,,STK
49.9,desc,"R35,R40,R41,R43,",0805_R,libref,2,4,,,STK
330,desc,"R36,R38,",0805_R,libref,2,2,,,STK
18K,desc,"R37,R46,",0805_R,libref,2,2,,,STK
12.1K 1%,desc,"R39,",0805_R,libref,2,1,,,STK
51,desc,"R51,R52,",0805_R,libref,2,2,,,STK
1K1/2,desc,"R53,",R_1812_4532Metric_Pad1.30x3.40mm_HandSolder,libref,2,1,,,STK
200,desc,"R54,R69,R70,",0805_R,libref,2,3,,,STK
220,desc,"R55,",0805_R,libref,2,1,,,STK
120,desc,"R61,",0805_R,libref,2,1,,,STK
25K,desc,"R64,",0805_R,libref,2,1,,,STK
150K,desc,"R65,",0805_R,libref,2,1,,,STK
ESP32-WROOM-32,desc,"U2,",ESP32-WROOM-32,libref,39,1,,,TB_BOUGHT
LM317_TO-220,desc,"U3,",TO-252-2,libref,7,1,,,STK
L78L05_SOT89,desc,"U4,",SOT-89(SOT-89-3),libref,4,1,,,STK
AMS1117-3.3,desc,"U5,",SOT-223,libref,4,1,,,STK
LAN8720A,desc,"U7,",QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm,libref,29,1,,,STK
PCA9555PW,desc,"U8,",TSSOP-24_4.4x7.8mm_P0.65mm,libref,24,1,,,LC
HCNR201,desc,"U9,U15,",SMDIP-8_W11.48mm,libref,8,2,,,YX
EL357,desc,"U10,U12,U18,U19,U20,",SOP-4_P2.54,libref,4,5,,,STK
LM358,desc,"U14,",SOIC-8_150MIL,libref,8,1,,,STK
LMV358,desc,"U17,",SOIC-8_150MIL,libref,8,1,,,STK
MAX485E,desc,"U21,",SOIC-8_150MIL,libref,8,1,,,STK
SW_SPST,desc,"SW1,",SW_SPST_TS_1101,libref,2,1,,,STK
Power,desc,"J4,",PinSocket_2x05_P2.54mm_Vertical_SMD,libref,10,1,,,STK
Control Signals,desc,"J5,",PinSocket_2x05_P2.54mm_Vertical_SMD,libref,10,1,,,STK
Sensor Feedback,desc,"J7,",PinSocket_2x05_P2.54mm_Vertical_SMD,libref,10,1,,,STK
Through Hole Items ,,,,,,,,,
100uF,desc,"C2,",CP_Radial_D5.0mm_P2.50mm,libref,2,1,,,STK
1000uF 63V,desc,"C4,",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,libref,2,1,,,STK
1000uF 63V,desc,"C31,",CP_Radial_D16.0mm_P7.50mm,libref,2,1,,,STK
LED_12,desc,"D11,D12,",PinHeader_1x02_P2.54mm_Vertical,libref,2,2,,,STK
24VAC,desc,"J1,","PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal",libref,2,1,,,STK
JTAG,desc,"J3,",PinHeader_1x04_P2.54mm_Vertical,libref,4,1,,,STK
HR913550A,desc,"J6,",HR913550A,libref,16,1,,,YX
UART,desc,"J8,",PinHeader_1x04_P2.54mm_Vertical,libref,4,1,,,STK
POT,desc,"J9,J11,","PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal",libref,3,2,,,STK
LIMIT12,desc,"J10,","PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal",libref,3,1,,,STK
RS485,desc,"J12,","PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal",libref,3,1,,,STK
B1205-1W,desc,"U1,",B0505-2W,libref,6,1,,,YX
OLED_128x32_4pin,desc,"U6,",SSD1306-0.91-OLED-4pin-128x32,libref,4,1,,,TB
LMR16020,desc,"U11,",SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.514x3.2mm_ThermalVias,libref,20,1,,,LC
Prog,desc,"JP1,",Jumper_3P,libref,3,1,,,STK
Jumper-3pin,desc,"JP2,JP3,",Jumper_3P,libref,3,2,,,STK
VSEL,desc,"JP4,",Jumper_3P,libref,3,1,,,STK
Screw_Terminal_01x01,desc,"SC1,SC2,SC3,SC4,",M3_Screwhole,libref,7,4,,,STK
CW,desc,"SW2,",K8-7071,libref,6,1,,,STK
CCW,desc,"SW3,",K8-7071,libref,6,1,,,STK
SET,desc,"SW4,",K8-7071,libref,6,1,,,STK

## KiCad design PCB/motor_control_SPWM/motor_control.kicad_pcb

Parts:
C1: 10uF; 0805_C
C2, C3, C7, C9, C21, C22: 1uF; 0805_C
C4, C5, C6, C8, C19: 10uF; 1206_C
C10, C11, C12, C14: 104; 0805_C
C13, C15: 100uF 50V; CP_Elec_8x10.5
D1, D2, D3, D4: SD103; SOD-123
D5: 4148; SOD-123
F1: 15A; Fuseholder5x20
J1: Sensor Feedback; PinHeader_2x05_P2.54mm_Vertical_SMD
J2: Control Signals; PinHeader_2x05_P2.54mm_Vertical_SMD
J3: Power; PinHeader_2x05_P2.54mm_Vertical_SMD
J4: MOT1; PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal
J5: MOT2; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal
J6: Ground; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal
J7: DC in; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal
K1: G2RL-1-E
Q1: 8050; SOT-23(SOT-23-3)
R1, R2, R3, R4, R5, R11, R12, R13: 220; 0805_R
R6, R7, R8, R9, R10, R14, R15, R16: 4.7K; 0805_R
R17: 10K; 0805_R
R18, R19: 100; 0805_R
R28: 0; 1206_R
R29: 47K; 0805_R
SC1, SC2, SC3, SC4: M3; M3_Screwhole
TP2: H1INL; TestPoint_Pad_D1.0mm
TP3: H1INR; TestPoint_Pad_D1.0mm
TP4: H2INL; TestPoint_Pad_D1.0mm
TP5: H2INR; TestPoint_Pad_D1.0mm
TP6, TP7: GNDP; TestPoint_Pad_D1.0mm
U1, U2, U3, U4, U5, U6, U7, U8: LTV-357T; SO-4_4.4x3.6mm_P2.54mm
U9, U10, U11, U12: IR2104; SOIC-8_150MIL
U13, U14: CC6902-10A; SOIC-8_3.9x4.9mm_P1.27mm
U18: L78L05_SOT89; SOT-89(SOT-89-3)

Connections:
+3.3VISO: J2.2
+5V: C22.1, U1.4, U2.4, U3.4, U4.4, U5.4, U6.4, U7.4, U8.4, U18.1 (OUT); also elsewhere on the board
+5VISO: C1.1, C11.1, C14.1, J1.2, U13.8 (VCC), U14.8 (VCC); also elsewhere on the board
+12V: C2.1, C3.1, C7.1, C9.1, C19.1, C21.1, D1.1 (A), D2.1 (A), D3.1 (A), D4.1 (A), D5.1 (K), J3.10, K1.1, U9.1 (VCC), U10.1 (VCC), U11.1 (VCC), U12.1 (VCC), U18.3 (IN)
+VDC: C13.1, C15.1, F1.1, J7.1, R28.2
/+VDC_Out: J3.2, J3.4, J3.6, J3.8, R28.1
/BRAKE: R14.2, U6.3; also elsewhere on the board
/DIRREL1: R7.2, R17.1, U3.3
/Fused: F1.2, U13.1 (IP+), U13.2 (IP+), U14.1 (IP+), U14.2 (IP+)
/H1/LH: U9.7 (HO); also elsewhere on the board
/H1/LL: U9.5 (LO); also elsewhere on the board
/H1/RH: U11.7 (HO); also elsewhere on the board
/H1/RL: U11.5 (LO); also elsewhere on the board
/H1/VDD: U13.3 (IP-), U13.4 (IP-); also elsewhere on the board
/H1LO: C4.2, J4.3, U9.6 (VS); also elsewhere on the board
/H1RO: C6.2, K1.3, K1.6, U11.6 (VS); also elsewhere on the board
/H1SELL: R10.2, U1.3; also elsewhere on the board
/H1SELR: R6.2, U2.3; also elsewhere on the board
/H2/LH: U10.7 (HO); also elsewhere on the board
/H2/LL: U10.5 (LO); also elsewhere on the board
/H2/RH: U12.7 (HO); also elsewhere on the board
/H2/RL: U12.5 (LO); also elsewhere on the board
/H2/VDD: U14.3 (IP-), U14.4 (IP-); also elsewhere on the board
/H2SELL: R8.2, U4.3; also elsewhere on the board
/H2SELR: R9.2, U5.3; also elsewhere on the board
/MOT1_CCW: J4.1, K1.4, K1.5
/MOT1_CW: J4.2, K1.2, K1.7
/MOT2_N: C8.2, J5.1, U12.6 (VS); also elsewhere on the board
/MOT2_P: C5.2, J5.2, U10.6 (VS); also elsewhere on the board
/RELIN1: J2.1, R11.2
/RELIN2: J2.4, R1.2
/RELIN3: J2.3, R2.2
/RELIN4: J2.6, R3.2
/RELIN5: J2.5, R4.2
/RELIN6: J2.8, R5.2
/SDX: U9.3 (~SD), U10.3 (~SD), U11.3 (~SD), U12.3 (~SD); also elsewhere on the board
/SPWM1: J2.7, R13.2
/SPWM1_OUT: R16.2, U8.3; also elsewhere on the board
/SPWM2: J2.10, R12.2
/SPWM2_OUT: R15.2, U7.3; also elsewhere on the board
/VIOut1: C10.2, R18.1; also elsewhere on the board
/VIOut2: C12.2, R19.1; also elsewhere on the board
/VISenseOut1: J1.1; also elsewhere on the board
/VISenseOut2: J1.3; also elsewhere on the board
/logic/H1INL: TP2.1, U9.2 (IN); also elsewhere on the board
/logic/H1INR: TP3.1, U11.2 (IN); also elsewhere on the board
/logic/H2INL: TP4.1, U10.2 (IN); also elsewhere on the board
/logic/H2INR: TP5.1, U12.2 (IN); also elsewhere on the board
GNDPWR: C2.2, C3.2, C7.2, C9.2, C13.2, C15.2, C19.2, C21.2, C22.2, J3.1, J3.3, J3.5, J3.7, J3.9, J6.1, J6.2, J7.2, Q1.2 (E), R6.1, R7.1, R8.1, R9.1, R10.1, R14.1, R15.1, R16.1, R29.2, TP6.1, TP7.1, U9.4 (COM), U10.4 (COM), U11.4 (COM), U12.4 (COM), U18.2 (GND); also elsewhere on the board
GNDS: C1.2, C10.1, C11.2, C12.1, C14.2, J1.9, J2.9, U1.2, U2.2, U3.2, U4.2, U5.2, U6.2, U7.2, U8.2, U13.5 (GND), U14.5 (GND); also elsewhere on the board
unnamed: C4.1, D1.2 (K), U9.8 (VB)
unnamed: C5.1, D2.2 (K), U10.8 (VB)
unnamed: C6.1, D3.2 (K), U11.8 (VB)
unnamed: C8.1, D4.2 (K), U12.8 (VB)
unnamed: D5.2 (A), K1.8, Q1.3 (C)
unnamed: Q1.1 (B), R17.2, R29.1
unnamed: R1.1, U1.1
unnamed: R2.1, U2.1
unnamed: R3.1, U3.1
unnamed: R4.1, U4.1
unnamed: R5.1, U5.1
unnamed: R11.1, U6.1
unnamed: R12.1, U7.1
unnamed: R13.1, U8.1
unnamed: R18.2, U13.7 (VIOUT)
unnamed: R19.2, U14.7 (VIOUT)

Notes on the sheet:
Non Isolated
