# Repository LuZening/RotatorInterface (continued)

## KiCad design PCB/motor_control_SPWM/motor_control.kicad_pcb (continued)

Parts:
C16, C20: 104; 0805_C
R20, R21, R30, R31, R32, R33: 22; 0805_R
R26, R27: 100; 0805_R
U15: 74HC00; SOIC-14_150MIL
U17: 74HC04; SOIC-14_150MIL

Connections:
+5V: C16.1, C20.1, U15.14 (VCC), U17.13, U17.14 (VCC); also elsewhere on the board
/BRAKE: R26.1, U17.11; also elsewhere on the board
/H1SELL: U15.1; also elsewhere on the board
/H1SELR: U15.4; also elsewhere on the board
/H2SELL: U15.9; also elsewhere on the board
/H2SELR: U15.12; also elsewhere on the board
/SDX: R26.2, R27.2; also elsewhere on the board
/SPWM1_OUT: R20.1; also elsewhere on the board
/SPWM2_OUT: R21.1; also elsewhere on the board
/logic/H1INL: R30.1; also elsewhere on the board
/logic/H1INR: R32.1; also elsewhere on the board
/logic/H2INL: R31.1; also elsewhere on the board
/logic/H2INR: R33.1; also elsewhere on the board
GNDPWR: C16.2, C20.2, U15.7 (GND), U17.7 (GND); also elsewhere on the board
unnamed: R20.2, U15.2, U15.5
unnamed: R21.2, U15.10, U15.13
unnamed: R27.1, U17.10
unnamed: R30.2, U17.2
unnamed: R31.2, U17.6
unnamed: R32.2, U17.4
unnamed: R33.2, U17.8
unnamed: U15.3, U17.1
unnamed: U15.6, U17.3
unnamed: U15.8, U17.5
unnamed: U15.11, U17.9

Parts:
D6, D7, D8, D9: 4148; SOD-123
Q6, Q7, Q8, Q9: IRFS4310Z; TO-252-2
R34, R35, R40, R41: 10; 0805_R
R36, R37, R38, R39: 100K; 0805_R

Connections:
/H1/LH: D6.2 (K), R34.2; also elsewhere on the board
/H1/LL: D7.2 (K), R35.2; also elsewhere on the board
/H1/RH: D8.2 (K), R40.2; also elsewhere on the board
/H1/RL: D9.2 (K), R41.2; also elsewhere on the board
/H1/VDD: Q6.2 (D), Q8.2 (D); also elsewhere on the board
/H1LO: Q6.3 (S), Q7.2 (D), R36.1; also elsewhere on the board
/H1RO: Q8.3 (S), Q9.2 (D), R38.2; also elsewhere on the board
GNDPWR: Q7.3 (S), Q9.3 (S), R37.1, R39.2; also elsewhere on the board
unnamed: D6.1 (A), Q6.1 (G), R34.1, R36.2
unnamed: D7.1 (A), Q7.1 (G), R35.1, R37.2
unnamed: D8.1 (A), Q8.1 (G), R38.1, R40.1
unnamed: D9.1 (A), Q9.1 (G), R39.1, R41.1

Parts of its further copies:
D10, D11, D12, D13: 4148; SOD-123
Q10, Q11, Q12, Q13: IRFS4310Z; TO-252-2
R50, R51, R56, R57: 10; 0805_R
R52, R53, R54, R55: 100K; 0805_R

Connections of its further copies:
/H2/LH: D10.2 (K), R50.2; also elsewhere on the board
/H2/LL: D11.2 (K), R51.2; also elsewhere on the board
/H2/RH: D12.2 (K), R56.2; also elsewhere on the board
/H2/RL: D13.2 (K), R57.2; also elsewhere on the board
/H2/VDD: Q10.2 (D), Q12.2 (D); also elsewhere on the board
/MOT2_N: Q12.3 (S), Q13.2 (D), R54.2; also elsewhere on the board
/MOT2_P: Q10.3 (S), Q11.2 (D), R52.1; also elsewhere on the board
GNDPWR: Q11.3 (S), Q13.3 (S), R53.1, R55.2; also elsewhere on the board
unnamed: D10.1 (A), Q10.1 (G), R50.1, R52.2
unnamed: D11.1 (A), Q11.1 (G), R51.1, R53.2
unnamed: D12.1 (A), Q12.1 (G), R54.1, R56.1
unnamed: D13.1 (A), Q13.1 (G), R55.1, R57.1

Parts:
C17, C18: 104; 0805_C
R22, R23, R24, R25, R45, R47, R48, R49: 1K; 0805_R
R42: 51K; 0805_R
R43: 47K; 0805_R
TP8: VIS1; TestPoint_Pad_D1.0mm
TP9: VIS2; TestPoint_Pad_D1.0mm
TP10: VID1; TestPoint_Pad_D1.0mm
TP11: VID2; TestPoint_Pad_D1.0mm
TP12: GNDS; TestPoint_Pad_D1.0mm
TP13: VMID; TestPoint_Pad_D1.0mm
U16: LM324; SOIC-14_150MIL

Connections:
+5VISO: C18.2, R42.1, U16.4 (V+); also elsewhere on the board
/CurrentSensing/VMID: R45.2, R47.2, TP13.1, U16.1, U16.2 (-)
/VIOut1: R22.2, TP8.1; also elsewhere on the board
/VIOut2: R23.2, TP9.1; also elsewhere on the board
/VISenseOut1: R48.2, TP10.1, U16.7; also elsewhere on the board
/VISenseOut2: R49.2, TP11.1, U16.8; also elsewhere on the board
GNDS: C17.2, C18.1, R24.1, R25.1, R43.2, TP12.1, U16.11 (V-), U16.12 (+); also elsewhere on the board
unnamed: C17.1, R42.2, R43.1, U16.3 (+)
unnamed: R22.1, R24.2, U16.5 (+)
unnamed: R23.1, R25.2, U16.10 (+)
unnamed: R45.1, R48.1, U16.6 (-)
unnamed: R47.1, R49.1, U16.9 (-)
unnamed: U16.13 (-), U16.14

Notes on the sheet:
Decenterized
2.4V

Board: 2 copper layers, 100.0 x 75.0 mm, 142 parts (20 on the bottom side), 91 nets.

File PCB/motor_control_SPWM/motor_control_BOM.csv:

Comment,Description,Designator,Footprint,LibRef,Pins,Quantity,PartNumber,url,¹ºÂò
10uF,desc,"C1,",0805_C,libref,2,1,,,STK
1uF,desc,"C2,C3,C7,C9,C21,C22,",0805_C,libref,2,6,,,STK
10uF,desc,"C4,C5,C6,C8,C19,",1206_C,libref,2,5,,,STK
104,desc,"C10,C11,C12,C14,C16,C17,C18,C20,",0805_C,libref,2,8,,,STK
SD103,desc,"D1,D2,D3,D4,",SOD-123,libref,2,4,,,STK
4148,desc,"D5,D6,D7,D8,D9,D10,D11,D12,D13,",SOD-123,libref,2,9,,,STK
Sensor Feedback,desc,"J1,",PinHeader_2x05_P2.54mm_Vertical_SMD,libref,10,1,,,STK
Control Signals,desc,"J2,",PinHeader_2x05_P2.54mm_Vertical_SMD,libref,10,1,,,STK
Power,desc,"J3,",PinHeader_2x05_P2.54mm_Vertical_SMD,libref,10,1,,,STK
8050,desc,"Q1,",SOT-23(SOT-23-3),libref,3,1,,,STK
IRFS4310Z,desc,"Q6,Q7,Q8,Q9,Q10,Q11,Q12,Q13,",TO-252-2,libref,3,8,,,STK
220,desc,"R1,R2,R3,R4,R5,R11,R12,R13,",0805_R,libref,2,8,,,STK
4.7K,desc,"R6,R7,R8,R9,R10,R14,R15,R16,",0805_R,libref,2,8,,,STK
10K,desc,"R17,",0805_R,libref,2,1,,,STK
100,desc,"R18,R19,R26,R27,",0805_R,libref,2,4,,,STK
22,desc,"R20,R21,R30,R31,R32,R33,",0805_R,libref,2,6,,,STK
1K,desc,"R22,R23,R24,R25,R45,R47,R48,R49,",0805_R,libref,2,8,,,STK
0,desc,"R28,",1206_R,libref,2,1,,,STK
47K,desc,"R29,R43,",0805_R,libref,2,2,,,STK
10,desc,"R34,R35,R40,R41,R50,R51,R56,R57,",0805_R,libref,2,8,,,STK
100K,desc,"R36,R37,R38,R39,R52,R53,R54,R55,",0805_R,libref,2,8,,,STK
51K,desc,"R42,",0805_R,libref,2,1,,,STK
LTV-357T,desc,"U1,U2,U3,U4,U5,U6,U7,U8,",SO-4_4.4x3.6mm_P2.54mm,libref,4,8,,,STK
IR2104,desc,"U9,U10,U11,U12,",SOIC-8_150MIL,libref,8,4,,,YX
CC6902-10A,desc,"U13,U14,",SOIC-8_3.9x4.9mm_P1.27mm,libref,8,2,,,LC
74HC00,desc,"U15,",SOIC-14_150MIL,libref,14,1,,,STK
LM324,desc,"U16,",SOIC-14_150MIL,libref,14,1,,,STK
74HC04,desc,"U17,",SOIC-14_150MIL,libref,14,1,,,STK
L78L05_SOT89,desc,"U18,",SOT-89(SOT-89-3),libref,4,1,,,STK
100uF 50V,desc,"C13,C15,",CP_Elec_8x10.5,libref,2,2,,,STK
H1INL,desc,"TP2,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
H1INR,desc,"TP3,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
H2INL,desc,"TP4,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
H2INR,desc,"TP5,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
GNDP,desc,"TP6,TP7,",TestPoint_Pad_D1.0mm,libref,1,2,,,STK
VIS1,desc,"TP8,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
VIS2,desc,"TP9,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
VID1,desc,"TP10,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
VID2,desc,"TP11,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
GNDS,desc,"TP12,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
VMID,desc,"TP13,",TestPoint_Pad_D1.0mm,libref,1,1,,,STK
Through Hole Items ,,,,,,,,,
M3,desc,"SC1,SC2,SC3,SC4,",M3_Screwhole,libref,7,4,,,STK
15A,desc,"F1,",Fuseholder5x20,libref,2,1,,,STK
MOT1,desc,"J4,","PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal",libref,3,1,,,STK
MOT2,desc,"J5,","PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal",libref,2,1,,,STK
Ground,desc,"J6,","PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal",libref,2,1,,,STK
DC in,desc,"J7,","PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal",libref,2,1,,,STK
G2RL-1-E,desc,"K1,",G2RL-1-E,libref,8,1,,,STK

## KiCad design PCB/motor_control/motor_control.kicad_pcb

Parts:
C1, C2, C3: 104; 0805_C
C4, C5, C6: 103 100V; 1210_C
D1, D2, D3, D4: 1N4148; SOD-123
F1: 15A; Fuseholder5x20
J1, J2: Screw; M3_Screwhole
J5: Power; PinHeader_2x05_P2.54mm_Vertical_SMD
J6: Control Signals; PinHeader_2x05_P2.54mm_Vertical_SMD
J7: Sensor; PinHeader_2x05_P2.54mm_Vertical_SMD
J8: MOT1; PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal
J9: TRIAC_AUX1; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal
J11: MOT2; PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal
J12: AC in; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal
K1, K2, K3, K4: G2RL-1-E
Q1, Q2, Q3: BT138; TO-252-2
Q1B1, Q2B1: BT138; TO-220_External_Thermal_Mount_Short
R1, R2, R3, R4, R5, R6, R7: 220; 0805_R
R8, R9, R13: 100; 1206_R
R10, R11, R12, R14: 10K; 0805_R
R17, R18, R19: 33; 1206_R
R20: 100; 0805_R
U1, U4, U7: MOC3063M; SMDIP-6_W9.53mm
U2, U3, U5, U6: EL357; SOP-4_P2.54
U8: ULN2003; SOIC-16_150MIL
U9: ACS712/CC6902; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: J6.2
+5V: C2.2, J7.2, U9.8 (VCC)
+12V: D1.2 (K), D2.2 (K), D3.2 (K), D4.2 (K), J5.10, K1.1, K2.1, K3.1, K4.1, U2.4, U3.4, U5.4, U6.4, U8.9 (COM)
/AC_MOT1: C5.2, K1.3, K1.6, Q2.1 (A1), Q2B1.1 (A1)
/AC_MOT1_SW: K1.4, K1.5, K2.3, K2.6
/AC_MOT2: C6.2, K3.3, K3.6, Q3.1 (A1)
/AC_MOT2_SW: K3.4, K3.5, K4.3, K4.6
/AC_Mot: Q2.2 (A2), Q2B1.2 (A2), Q3.2 (A2), R9.1, R13.1, R18.2, R19.2, U9.3 (IP-), U9.4 (IP-)
/AC_in: F1.2, Q1.2 (A2), Q1B1.2 (A2), R8.1, R17.2, U9.1 (IP+), U9.2 (IP+)
/AUX1: C4.2, J9.1, Q1.1 (A1), Q1B1.1 (A1)
/ISense1: C3.1, J7.1, R20.1
/MOT1CCW: J8.1, K2.2, K2.7
/MOT1CW: J8.2, K2.4, K2.5
/MOT2CCW: J11.1, K4.2, K4.7
/MOT2CW: J11.2, K4.4, K4.5
/RELOUT1: J6.1, R2.1
/RELOUT2: J6.4, R3.1
/RELOUT3: J6.3, R5.1
/RELOUT4: J6.6, R6.1
/RELOUT5: J6.5, R7.1
/RELOUT6: J6.8
/SPWM1: J6.7, R1.2
/SPWM2: J6.10, R4.1
GNDPWR: J5.1, J5.3, J5.5, J5.7, J5.9, J8.3, J9.2, J11.3, J12.2, U8.5 (I5), U8.6 (I6), U8.7 (I7), U8.8 (GND)
GNDS: C1.2, C2.1, C3.2, J6.9, J7.9, U1.2, U2.2, U3.2, U4.2, U5.2, U6.2, U7.2, U9.5 (GND)
unnamed: C1.1, U9.6 (FILTER)
unnamed: C4.1, R8.2
unnamed: C5.1, R9.2
unnamed: C6.1, R13.2
unnamed: D1.1 (A), K2.8, U8.15 (O2)
unnamed: D2.1 (A), K3.8, U8.14 (O3)
unnamed: D3.1 (A), K4.8, U8.13 (O4)
unnamed: D4.1 (A), K1.8, U8.16 (O1)
unnamed: K1.2, K1.7
unnamed: K3.2, K3.7
unnamed: Q1.3 (G), Q1B1.3 (G), U7.4
unnamed: Q2.3 (G), Q2B1.3 (G), U1.4
unnamed: Q3.3 (G), U4.4
unnamed: R1.1, U1.1
unnamed: R2.2, U2.1
unnamed: R3.2, U3.1
unnamed: R4.2, U4.1
unnamed: R5.2, U5.1
unnamed: R6.2, U6.1
unnamed: R7.2, U7.1
unnamed: R10.1, U2.3
unnamed: R10.2, U8.1 (I1)
unnamed: R11.1, U3.3
unnamed: R11.2, U8.2 (I2)
unnamed: R12.1, U5.3
unnamed: R12.2, U8.3 (I3)
unnamed: R14.1, U6.3
unnamed: R14.2, U8.4 (I4)
unnamed: R17.1, U7.6
unnamed: R18.1, U4.6
unnamed: R19.1, U1.6
unnamed: R20.2, U9.7 (VIOUT)
VAC: F1.1, J5.2, J5.4, J5.6, J5.8, J12.1

Notes on the sheet:
Output Stage
Snubber

Board: 2 copper layers, 100.0 x 75.0 mm, 56 parts (9 on the bottom side), 56 nets.

File PCB/motor_control/motor_control_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"104","desc","C1,C2,C3,","0805_C","libref","2","3","","",
"103 100V","desc","C4,C5,C6,","1210_C","libref","2","3","","",
"Power","desc","J5,","PinHeader_2x05_P2.54mm_Vertical_SMD","libref","10","1","","",
"Control Signals","desc","J6,","PinHeader_2x05_P2.54mm_Vertical_SMD","libref","10","1","","",
"Sensor","desc","J7,","PinHeader_2x05_P2.54mm_Vertical_SMD","libref","10","1","","",
"BT138","desc","Q1,Q2,Q3,","TO-252-2","libref","7","3","","",
"220","desc","R1,R2,R3,R4,R5,R6,R7,","0805_R","libref","2","7","","",
"100","desc","R8,R9,R13,","1206_R","libref","2","3","","",
"10K","desc","R10,R11,R12,R14,","0805_R","libref","2","4","","",
"33","desc","R17,R18,R19,","1206_R","libref","2","3","","",
"100","desc","R20,","0805_R","libref","2","1","","",
"MOC3063M","desc","U1,U4,U7,","SMDIP-6_W9.53mm","libref","6","3","","",
"EL357","desc","U2,U3,U5,U6,","SOP-4_P2.54","libref","4","4","","",
"ULN2003","desc","U8,","SOIC-16_150MIL","libref","16","1","","",
"ACS712xLCTR-30A","desc","U9,","SOIC-8_3.9x4.9mm_P1.27mm","libref","8","1","","",
"Through Hole Items ",
"Screw","desc","J1,J2,","M3_Screwhole","libref","7","2","","",
"BT138","desc","Q1B1,Q2B1,","TO-220_External_Thermal_Mount_Short","libref","4","2","","",
"15A","desc","F1,","Fuseholder5x20","libref","2","1","","",
"MOT1","desc","J8,","PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal","libref","3","1","","",
"TRIAC_AUX1","desc","J9,","PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal","libref","2","1","","",
"MOT2","desc","J11,","PhoenixContact_MSTBA_2,5_3-G-5,08_1x03_P5.08mm_Horizontal","libref","3","1","","",
"AC in","desc","J12,","PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal","libref","2","1","","",
"G2RL-1-E","desc","K1,K2,K3,K4,","G2RL-1-E","libref","8","4","","",
