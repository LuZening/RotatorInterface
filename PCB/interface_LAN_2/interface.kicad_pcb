# Repository LuZening/RotatorInterface (continued)

## KiCad design PCB/interface/interface.kicad_pcb

Parts:
C1, C8: 225; 0805
C2, C9, C11: 100uF; CP_Radial_D5.0mm_P2.50mm
C3, C6, C7, C10, C13, C14, C15, C16, C17, C18, C19, C20: 104; 0805
C4: 2200uF 50V; CP_Radial_D16.0mm_P7.50mm
C5: 10uF; CP_Radial_D5.0mm_P2.50mm
C12: 100uF 50V; CP_Radial_D8.0mm_P3.50mm
D1: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D2, D8, D9: D_TVS; D_SMB
D3, D5: GRN; LED_0805
D4, D6: RED; LED_0805
D7: LED; LED_0805
F1: 15A; Fuseholder5x20
F2, F3: 6.8V0.1A; 0805
J1: 24VAC; 508CON-2P
J2: Brake; 508CON-2P
J3: Motor; 508CON-2P
J4: Limit; 508CON-2P
J5: LED_G; XH2.54-2
J6: Ground; 508CON-2P
J7: LED_B; XH2.54-2
J8: UART; XH2.54-4
J9: POT; 508CON-3P
J10: RS485; 508CON-3P
JP1, JP2, JP3: Jumper-3pin; Jumper_3P
JP4, JP5, JP6, JP7: Bridge
K1, K2, K3, K4: G2R-1-E; OMRON G2R-1-E
R1, R2: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R33, R39, R46: 4.7K; 0805
R4, R7, R9, R12, R15, R20, R21, R23: 47K; 0805
R5: 4K7; 0805
R6, R8, R10, R11, R17, R22, R32, R43: 220; 0805
R13, R14, R35, R42: 1K; 0805
R16, R24, R25, R26, R36, R44, R45: 10K; 0805
R18, R19, R34: 100; 0805
R28: 1K 1W; R_Axial_DIN0411_L9.9mm_D3.6mm_P5.08mm_Vertical
R29: 220K; 0805
R30: 1k 1W; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R31: 51; 0805
R37, R38: 18K; 0805
R40: 120; 0805
R41: 470; 0805
SW1: SW_SPST; SW_PUSH_6mm
U1, U3: DCDC-isolator; B0505-2W
U2: L7812; TO-220-3_Vertical
U4: ULN2003A; SOIC-16_3.9x9.9mm_Pitch1.27mm
U5: AMS1117-3.3; SOT-223-3_TabPin2
U6, U7, U8, U9, U10, U16: PC817; DIP-4_W7.62mm
U11: 74HCT595; SOIC-16_3.9x9.9mm_Pitch1.27mm
U12: ESP-07; ESP-07S
U13: AT24C64; SOIC-8_3.9x4.9mm_Pitch1.27mm
U14, U17: LM358; SOIC-8_3.9x4.9mm_Pitch1.27mm
U15: HCNR201; DIP-8_W10.16mm
U18, U20: 6N137; DIP-8_W7.62mm
U19: MAX485E; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+3V3: C11.1, C13.2, C14.1, C15.2, C17.1, C19.2, D3.2 (A), D4.2 (A), J5.1, J7.1, J8.1, R3.2, R13.2, R14.2, R16.1, R24.2, R25.2, R32.1, R39.1, R43.1, R45.1, U5.2 (VO), U6.1, U8.1, U9.1, U10.1, U11.10 (~SRCLR), U11.16 (VCC), U12.8 (VCC), U13.8 (VDD), U17.8 (V+), U18.8
+5V: C2.1, C3.1, R1.1, U1.4 (OUT+), U5.3 (VI)
+5VD: C9.1, C10.1, C18.1, C20.1, R2.1, R41.2, R42.1, R44.1, U3.4 (OUT+), U16.4, U19.8 (VCC), U20.8
+24V: C1.1, C7.1, C8.1, C16.1, K1.1, K2.1, K3.1, K4.1, R28.2, R30.2, U1.1 (IN+), U2.3 (OUT), U3.1 (IN+), U4.9 (COM), U6.4, U8.4, U9.4, U10.4, U14.8 (V+)
/24VAC-master: J2.2, K1.3, K1.6, K2.4, K2.5, K3.4, K3.5, K4.4, K4.5
/A485: F3.1, J10.3
/B485: F2.1, J10.1
/PGSW1: J2.1, K2.3, K2.6
/PGSW2: J3.2, K3.3, K3.6
/PGSW3: J3.1, K4.3, K4.6
/SCL: JP1.2, R24.1, U12.12 (GPIO0), U13.6 (SCL)
/SDA: R25.1, U12.5 (GPIO14), U13.5 (SDA)
Earth: C9.2, C10.2, C18.2, C20.2, D8.2 (A2), D9.1 (A1), J10.2, R2.2, R33.2, R35.2, U3.3 (OUT-), U19.5 (GND), U20.5
GNDPWR: C1.2, C4.2, C5.2, C6.2, C7.2, C8.2, C12.2, C16.2, D2.2 (A2), J1.2, J4.2, J6.1, J6.2, J9.3, JP4.2, JP5.2, JP6.2, JP7.2, R7.1, R12.1, R20.1, R23.1, U1.2 (IN-), U2.2 (GND), U3.2 (IN-), U4.5 (I5), U4.6 (I6), U4.7 (I7), U4.8 (GND), U7.2, U14.3 (+), U14.4 (V-), U15.4
GNDS: C2.2, C3.2, C11.2, C13.1, C14.2, C15.1, C17.2, C19.1, D7.1 (K), J8.4, JP1.3, R1.2, R26.1, R36.1, SW1.1 (A), U1.3 (OUT-), U5.1 (GND), U7.3, U11.8 (GND), U12.9 (GND), U13.1 (A0), U13.2 (A1), U13.3 (A2), U13.4 (VSS), U15.5, U17.3 (+), U17.4 (V-), U18.5
LIMIT: R3.1, U7.4, U12.4 (GPIO16)
unnamed: C4.1, C5.1, C6.1, D1.1 (K), U2.1 (IN)
unnamed: C12.1, J4.1, R5.1
unnamed: D3.1 (K), R8.2
unnamed: D4.1 (K), R10.2
unnamed: D5.2 (A), R13.1
unnamed: D6.2 (A), R14.1
unnamed: D8.1 (A1), F2.2, R35.1, R40.2, U19.7 (B)
unnamed: D9.2 (A2), F3.2, R40.1, R42.2, U19.6 (A)
unnamed: F1.2, J1.1
unnamed: J5.2, R8.1, U11.1 (QB)
unnamed: J7.2, R10.1, U11.15 (QA)
unnamed: J8.2, R18.2
unnamed: J8.3, R19.2
unnamed: J9.1, JP2.1, R30.1
unnamed: J9.2, R31.1
unnamed: JP2.2, R29.2, R31.2
unnamed: JP3.2, R38.2, U15.6, U17.2 (-)
unnamed: JP3.3, R37.2, R38.1
unnamed: JP4.1, K1.2, K1.7
unnamed: JP5.1, K2.2, K2.7
unnamed: JP6.1, K3.2, K3.7
unnamed: JP7.1, K4.2, K4.7
unnamed: K1.8, U4.16 (O1)
unnamed: K2.8, U4.15 (O2)
unnamed: K3.8, U4.14 (O3)
unnamed: K4.8, U4.13 (O4)
unnamed: R4.1, R7.2, U6.3
unnamed: R4.2, U4.1 (I1)
unnamed: R5.2, U7.1
unnamed: R6.1, U11.5 (QF)
unnamed: R6.2, U6.2
unnamed: R9.2, U4.2 (I2)
unnamed: R11.1, U11.4 (QE)
unnamed: R11.2, U8.2
unnamed: R9.1, R12.2, U8.3
unnamed: R15.1, R20.2, U9.3
unnamed: R15.2, U4.3 (I3)
unnamed: R16.2, U12.3 (EN)
unnamed: R17.1, U11.3 (QD)
unnamed: R17.2, U9.2
unnamed: R21.1, R23.2, U10.3
unnamed: R21.2, U4.4 (I4)
unnamed: R22.1, U11.2 (QC)
unnamed: R22.2, U10.2
unnamed: R26.2, U12.10 (GPIO15)
unnamed: R28.1, U15.2
unnamed: R29.1, U14.2 (-), U15.3
unnamed: R32.2, U16.1
unnamed: R33.1, R46.1, U16.3
unnamed: R34.1, R36.2, R37.1, U17.1
unnamed: R41.1, U18.2
unnamed: R43.2, U20.2
unnamed: R44.2, U19.4 (DI), U20.6
unnamed: R45.2, U11.13 (~OE), U12.11 (GPIO2)
unnamed: R46.2, U19.2 (~RE), U19.3 (DE)
unnamed: SW1.2 (B), U12.1 (~RST)
unnamed: U11.6 (QG), U13.7 (WP)
unnamed: U11.11 (SRCLK), U12.6 (GPIO12)
unnamed: U11.12 (RCLK), U12.7 (GPIO13)
unnamed: U11.14 (SER), U12.13 (GPIO4)
unnamed: U14.1, U15.1
unnamed: U18.3, U19.1 (RO)
POT: D7.2 (A), R34.2, U12.2 (ADC)
RW: U12.14 (GPIO5), U16.2
RXD: D5.1 (K), R18.1, R39.2, U12.15 (GPIO3/RXD), U18.6
TXD: D6.1 (K), R19.1, U12.16 (GPIO1/TXD), U20.3
VAC: D1.2 (A), D2.1 (A1), F1.1, K1.4, K1.5

Notes on the sheet:
485 POWER
CPU POWER
0.1-1V
Angular Signal Aquisition
Power Supply
RS485
GAIN: 0.5X 1X

Board: 2 copper layers, 100.0 x 100.0 mm, 120 parts (4 on the bottom side), 83 nets.

Other parts of the board:
Ref**: Heatsink_23mm_2P

File PCB/interface/interface_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"225","desc","C1,C8,","0805","libref","2","2","","",
"104","desc","C3,C6,C7,C10,C13,C14,C15,C16,C17,C18,C19,C20,","0805","libref","2","12","","",
"D_TVS","desc","D2,D8,D9,","D_SMB","libref","2","3","","",
"GRN","desc","D3,D5,","LED_0805","libref","2","2","","",
"RED","desc","D4,D6,","LED_0805","libref","2","2","","",
"LED","desc","D7,","LED_0805","libref","2","1","","",
"6.8V0.1A","desc","F2,F3,","0805","libref","2","2","","",
"4.7K","desc","R3,R33,R39,R46,","0805","libref","2","4","","",
"47K","desc","R4,R7,R9,R12,R15,R20,R21,R23,","0805","libref","2","8","","",
"4K7","desc","R5,","0805","libref","2","1","","",
"220","desc","R6,R8,R10,R11,R17,R22,R32,R43,","0805","libref","2","8","","",
"1K","desc","R13,R14,R35,R42,","0805","libref","2","4","","",
"10K","desc","R16,R24,R25,R26,R36,R44,R45,","0805","libref","2","7","","",
"100","desc","R18,R19,R34,","0805","libref","2","3","","",
"220K","desc","R29,","0805","libref","2","1","","",
"51","desc","R31,","0805","libref","2","1","","",
"18K","desc","R37,R38,","0805","libref","2","2","","",
"120","desc","R40,","0805","libref","2","1","","",
"470","desc","R41,","0805","libref","2","1","","",
"ULN2003A","desc","U4,","SOIC-16_3.9x9.9mm_Pitch1.27mm","libref","16","1","","",
"AMS1117-3.3","desc","U5,","SOT-223-3_TabPin2","libref","4","1","","",
"74HCT595","desc","U11,","SOIC-16_3.9x9.9mm_Pitch1.27mm","libref","16","1","","",
"ESP-07","desc","U12,","ESP-07S","libref","16","1","","",
"AT24C64","desc","U13,","SOIC-8_3.9x4.9mm_Pitch1.27mm","libref","8","1","","",
"LM358","desc","U14,U17,","SOIC-8_3.9x4.9mm_Pitch1.27mm","libref","8","2","","",
"MAX485E","desc","U19,","SOIC-8_3.9x4.9mm_Pitch1.27mm","libref","8","1","","",
"Bridge","desc","JP4,JP5,JP6,JP7,","Bridge","libref","2","4","","",
"Through Hole Items ",
"100uF","desc","C2,C9,C11,","CP_Radial_D5.0mm_P2.50mm","libref","2","3","","",
"2200uF 50V","desc","C4,","CP_Radial_D16.0mm_P7.50mm","libref","2","1","","",
"10uF","desc","C5,","CP_Radial_D5.0mm_P2.50mm","libref","2","1","","",
"100uF 50V","desc","C12,","CP_Radial_D8.0mm_P3.50mm","libref","2","1","","",
"1N4007","desc","D1,","D_DO-41_SOD81_P10.16mm_Horizontal","libref","2","1","","",
"15A","desc","F1,","Fuseholder5x20","libref","2","1","","",
"24VAC","desc","J1,","508CON-2P","libref","2","1","","",
"Brake","desc","J2,","508CON-2P","libref","2","1","","",
"Motor","desc","J3,","508CON-2P","libref","2","1","","",
"Limit","desc","J4,","508CON-2P","libref","2","1","","",
"LED_G","desc","J5,","XH2.54-2","libref","2","1","","",
"Ground","desc","J6,","508CON-2P","libref","2","1","","",
"LED_B","desc","J7,","XH2.54-2","libref","2","1","","",
"UART","desc","J8,","XH2.54-4","libref","4","1","","",
"POT","desc","J9,","508CON-3P","libref","3","1","","",
"RS485","desc","J10,","508CON-3P","libref","3","1","","",
"G2R-1-E","desc","K1,K2,K3,K4,","OMRON G2R-1-E","libref","8","4","","",
"220","desc","R1,R2,","R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","libref","2","2","","",
"1K 1W","desc","R28,","R_Axial_DIN0411_L9.9mm_D3.6mm_P5.08mm_Vertical","libref","2","1","","",
"1k 1W","desc","R30,","R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","libref","2","1","","",
"DCDC-isolator","desc","U1,U3,","B0505-2W","libref","6","2","","",
"L7812","desc","U2,","TO-220-3_Vertical","libref","3","1","","",
"PC817","desc","U6,U7,U8,U9,U10,U16,","DIP-4_W7.62mm","libref","4","6","","",
"HCNR201","desc","U15,","DIP-8_W10.16mm","libref","8","1","","",
"6N137","desc","U18,U20,","DIP-8_W7.62mm","libref","8","2","","",
"Jumper-3pin","desc","JP1,JP2,JP3,","Jumper_3P","libref","3","3","","",
"SW_SPST","desc","SW1,","SW_PUSH_6mm","libref","4","1","","",
"Heatsink_23mm_2P","desc","Ref**,","Heatsink_23mm_2P","libref","2","1","","",

## Code that names these connections

File MCU/MCU.ino (part):

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#endif

// Limit Switch Input
#define PIN_LIMIT 16

// 74595
#define PIN_DATA 4
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
// Relays
#define PIN_PGSW0 PIN_595(5)
#define PIN_PGSW1 PIN_595(4)
#define PIN_PGSW2 PIN_595(3)
#define PIN_PGSW3 PIN_595(2)

// Motor
#define PIN_BREAK PIN_PGSW0
#define PIN_MOTOR_P PIN_PGSW1
#define PIN_MOTOR_N PIN_PGSW2

// sensor
#define POT_TYPE TWO_TERMINALS
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    pinMode(PIN_SDA, OUTPUT_OPEN_DRAIN);
    pinMode(PIN_SCL, OUTPUT);
    pinMode(PIN_485RW, OUTPUT);
    pinMode(PIN_LIMIT, INPUT_PULLUP);

    //************** initializing vars **************//
    stat_LED_stat = 0;
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
## Commit log

2019-09-05 first release
2022-03-06 optimized map projection algo
2022-03-27 WS reconnection bug fixed
2022-05-15 New schemetic and PCB with support of Ethernet LAN connection
2022-05-16 Routed Interface_LAN MCU board
2022-06-23 Implemented the ESP-IDF version. First passed compilation
2022-11-11 motor control board with SPWM support`
2022-12-25 Implenting SPWM
